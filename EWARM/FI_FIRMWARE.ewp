# IAR project FI_FIRMWARE.ewp, settings and files
configuration STM32F407_Debug_500k_Sample_Data (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; SYSTEM_VIEW; __DEBUG
  ICCARM.CCIncludePath2: ../Core/STM32F4xx/Inc; ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Core/Packages/Debug/SystemView/SEGGER; ../Core/Packages/Debug/SystemView/Config; ../Core/Packages/Firmware/arm_math; ../Core/STM32F4xx/Configuration/500k_Sample_Data; ../Core/Packages/Debug/SerialWireDebug; ../Core/Packages/Firmware; ../Core/Packages/Firmware/Tasks; ../Core/Packages/Firmware/Interrupt_Callback
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc; ../Core/STM32F4xx/Inc
  OBJCOPY.OOCOutputFile: FI_FIRMWARE.hex
  ILINK.IlinkOutputFile: FI_FIRMWARE.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Stm32F407_Debug_10k_Sample_Data (ARM, debug)
  as the first configuration, except:
configuration STM32F407_Release_500k_Sample_Data (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Core/STM32F4xx/Inc; ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Core/Packages/Firmware/arm_math; ../Core/STM32F4xx/Configuration/500k_Sample_Data; ../Core/Packages/Firmware; ../Core/Packages/Firmware/Tasks; ../Core/Packages/Firmware/Interrupt_Callback
configuration STM32G4xx_Debug_500k_Sample_Data (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32G474RE ST STM32G474RE
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G474xx; SYSTEM_VIEW; __DEBUG
  ICCARM.CCIncludePath2: ../Core/STM32G4xx/Inc; ../Core/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../Drivers/CMSIS/Include; ../Core/Packages/Debug/SystemView/SEGGER; ../Core/Packages/Debug/SystemView/Config; ../Core/Packages/Firmware/arm_math; ../Core/STM32G4xx/Configuration/500k_Sample_Data; ../Core/Packages/Debug/SerialWireDebug; ../Core/Packages/Firmware; ../Core/Packages/Firmware/Tasks; ../Core/Packages/Firmware/Interrupt_Callback
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..\Core\Inc; ../Core/STM32G4xx/Inc
  ILINK.IlinkIcfFile: stm32g474xx_flash.icf
configuration STM32F407_Debug_NoHal_500k_Sample_Data (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F407xx; SYSTEM_VIEW; __DEBUG; STM32F407xx_NoHAL
  ICCARM.CCIncludePath2: ../Core/STM32F4xx_NoHAL/Inc; ../Core/Inc; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Core/Packages/Debug/SystemView/SEGGER; ../Core/Packages/Debug/SystemView/Config; ../Core/Packages/Debug/SerialWireDebugNoHAL; ../Core/Packages/Firmware/arm_math; ../Core/STM32F4xx_NoHAL/Configuration; ../Core/Packages/Firmware; ../Core/Packages/Firmware/Tasks
  ICCARM.CCOptLevel: 3
configuration STM32G4xx_Debug_10kSample (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32G474RE ST STM32G474RE
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G474xx; SYSTEM_VIEW; __DEBUG
  ICCARM.CCIncludePath2: ../Core/STM32G4xx/Inc; ../Core/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../Drivers/CMSIS/Include; ../Core/Packages/Debug/SystemView/SEGGER; ../Core/Packages/Debug/SystemView/Config; ../Core/Packages/Firmware/arm_math; ../Core/STM32G4xx/Configuration/10k_Sample_Data; ../Core/Packages/Debug/SerialWireDebug; ../Core/Packages/Firmware; ../Core/Packages/Firmware/Tasks; ../Core/Packages/Firmware/Interrupt_Callback
  AARM.AUserIncludes: ..\Core\Inc; ../Core/STM32G4xx/Inc
  ILINK.IlinkIcfFile: stm32g474xx_flash.icf
configuration STM32G4xx_Release_500k_Sample_Data (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32G474RE ST STM32G474RE
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G474xx
  ICCARM.CCIncludePath2: ../Core/STM32G4xx/Inc; ../Core/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../Drivers/CMSIS/Include; ../Core/Packages/Firmware/arm_math; ../Core/STM32G4xx/Configuration/500k_Sample_Data; ../Core/Packages/Firmware; ../Core/Packages/Firmware/Tasks; ../Core/Packages/Firmware/Interrupt_Callback
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..\Core\Inc; ../Core/STM32G4xx/Inc
  ILINK.IlinkIcfFile: stm32g474xx_flash.icf
configuration STM32F7_Debug_500k_Sample_Data (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; SYSTEM_VIEW; __DEBUG
  ICCARM.CCIncludePath2: ../Core/STM32F7xx/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS_10_2_1/Source/include; ../Middlewares/Third_Party/FreeRTOS_10_2_1/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS_10_2_1/Source/portable/IAR/ARM_CM7/r0p1; ../Drivers/CMSIS_2/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS_2/Include; ../Core/Packages/Debug/SystemView/SEGGER; ../Core/Packages/Debug/SystemView/Config; ../Core/Packages/Firmware/arm_math; ../Core/STM32F7xx/Configuration/500k_Sample_Data; ../Core/Packages/Debug/SerialWireDebug; ../Core/Packages/Firmware; ../Core/Packages/Firmware/Tasks; ../Core/Packages/Firmware/Interrupt_Callback
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..\Core\STM32F7xx\Inc
  ILINK.IlinkIcfFile: stm32f746xx_ITCM_flash.icf
configuration STM32F7_Debug_10k_Sample_Data (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; SYSTEM_VIEW; __DEBUG
  ICCARM.CCIncludePath2: as above
  AARM.AUserIncludes: ..\Core\STM32F7xx\Inc
  ILINK.IlinkIcfFile: stm32f746xx_ITCM_flash.icf
configuration STM32F7_Release_500k_Sample_Data (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCIncludePath2: ../Core/STM32F7xx/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS_10_2_1/Source/include; ../Middlewares/Third_Party/FreeRTOS_10_2_1/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS_10_2_1/Source/portable/IAR/ARM_CM7/r0p1; ../Drivers/CMSIS_2/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS_2/Include; ../Core/Packages/Firmware/arm_math; ../Core/STM32F7xx/Configuration/500k_Sample_Data; ../Core/Packages/Firmware; ../Core/Packages/Firmware/Tasks; ../Core/Packages/Firmware/Interrupt_Callback
  AARM.AUserIncludes: ..\Core\STM32F7xx\Inc
  ILINK.IlinkIcfFile: stm32f746xx_ITCM_flash.icf
configuration STM32F407_Release_NOHal_500k_Sample_Data (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F407xx; STM32F407xx_NoHAL
  ICCARM.CCIncludePath2: ../Core/STM32F4xx_NoHAL/Inc; ../Core/Inc; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Core/Packages/Firmware/arm_math; ../Core/STM32F4xx_NoHAL/Configuration; ../Core/Packages/Firmware; ../Core/Packages/Firmware/Tasks
  ICCARM.CCOptLevel: 3
  group Application/Debug/SerialWireDebug
    ../Core/Packages/Debug/SerialWireDebug/: DebugTest.c DebugTest.h
  group Application/Debug/SerialWireDebugNoHAL
    ../Core/Packages/Debug/SerialWireDebugNoHAL/: DebugTest.c DebugTest.h
  group Application/Debug/SystemView/Config
    ../Core/Packages/Debug/SystemView/Config/: SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c
  group Application/Debug/SystemView/SEGGER
    ../Core/Packages/Debug/SystemView/SEGGER/: SEGGER_RTT.c SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_printf.c SEGGER_SYSVIEW.c
  group Application/Debug/SystemView/SEGGER/Syscalls
    ../Core/Packages/Debug/SystemView/SEGGER/Syscalls/: SEGGER_RTT_Syscalls_IAR.c
  group Application/EWARM
    ./: startup_stm32f407xx.s startup_stm32f746xx.s startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Packages/Firmware/: main.c main.h
  group Application/User/Core/packages/arm_math
    ../Core/Packages/Firmware/arm_math/: arm_rms_q15.c arm_sqrt_q15.c
  group Application/User/Core/processors/STM32F4xx
    ../Core/STM32F4xx/: initialize.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c
  group Application/User/Core/processors/STM32F4xx/Configuration/10k_Sample_Data
    ../Core/STM32F4xx/Configuration/10k_Sample_Data/: config.c config.h
  group Application/User/Core/processors/STM32F4xx/Configuration/500k_Sample_Data
    ../Core/STM32F4xx/Configuration/500k_Sample_Data/: config.c config.h
  group Application/User/Core/processors/STM32F4xx/Inc
    ../Core/STM32F4xx/Inc/: FreeRTOSConfig.h initialize.h stm32f4xx_hal_conf.h stm32f4xx_it.h
  group Application/User/Core/processors/Stm32F4xx_NoHAL
    ../Core/Stm32F4xx_NoHAL/: freertos.c initialize.c
  group Application/User/Core/processors/Stm32F4xx_NoHAL/Configuration
    ../Core/Stm32F4xx_NoHAL/Configuration/: config.c
    ../Core/STM32F4xx_NoHAL/Configuration/: config.h
  group Application/User/Core/processors/Stm32F4xx_NoHAL/Inc
    ../Core/STM32F4xx_NoHAL/Inc/: FreeRTOSConfig.h initialize.h
  group Application/User/Core/processors/STM32F7xx
    ../Core/STM32F7xx/: initialize.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c
  group Application/User/Core/processors/STM32F7xx/Configuration/10k_Sample_Data
    ../Core/STM32F7xx/Configuration/10k_Sample_Data/: config.c config.h
  group Application/User/Core/processors/STM32F7xx/Configuration/500k_Sample_Data
    ../Core/STM32F7xx/Configuration/500k_Sample_Data/: config.c config.h
  group Application/User/Core/processors/STM32F7xx/Inc
    ../Core/STM32F7xx/Inc/: FreeRTOSConfig.h initialize.h stm32f7xx_hal_conf.h stm32f7xx_it.h
  group Application/User/Core/processors/STM32G4xx
    ../Core/STM32G4xx/: initialize.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c stm32g4xx_it.c
  group Application/User/Core/processors/STM32G4xx/Configuration/10k_Sample_Data
    ../Core/STM32G4xx/Configuration/10k_Sample_Data/: config.c config.h
  group Application/User/Core/processors/STM32G4xx/Configuration/500k_Sample_Data
    ../Core/STM32G4xx/Configuration/500k_Sample_Data/: config.c config.h
  group Application/User/Core/processors/STM32G4xx/Inc
    ../Core/STM32G4xx/Inc/: FreeRTOSConfig.h initialize.h stm32g4xx_hal_conf.h stm32g4xx_it.h
  group Application/User/Core/RTOS/Initialization
    ../Core/Packages/Firmware/: InitFreeRtos.c InitFreeRtos.h
  group Application/User/Core/RTOS/Interrupt_Callback
    ../Core/Packages/Firmware/Interrupt_Callback/: DMA.c DMA.h
  group Application/User/Core/RTOS/Tasks
    ../Core/Packages/Firmware/Tasks/: calculation.c calculation.h highPrio.c highPrio.h mediumPrio.c mediumPrio.h
  group Drivers/CMSIS
    ../Core/STM32F4xx/: system_stm32f4xx.c
    ../Core/STM32F7xx/: system_stm32f7xx.c
    ../Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_adc.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_adc.c
  group Middlewares/FreeRTOS/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c freertos_os2.h
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/FreeRTOS/FreeRTOS_10_2_1
    ../Middlewares/Third_Party/FreeRTOS_10_2_1/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS_10_2_1/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS_10_2_1/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS_10_2_1/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
